# Repository ieb/BLEShunt

File README.md:

# BLEShunt

This is a Battery Shunt module that uses a JDY-25M to notifiy subscribing BLE Devices of current, voltage, power from 
a INA219 and 2 NTC temperature sensors. The BLE Device can be phones or ESP32's that are able to connect to the service
UUID and subscribe to the characteristics, both are non standard and statically defined inside the JDY-25M firmware.

The JDY-25M is normally in a light sleep consuming about 50uA, emitting advertisements every 3s. On connection the Attiny3224 wakes and starts emitting notifications of to the characteristic. During sleep the Attiny3225 and all other periperhals 
are put into deep sleep, hence the device should be capable of being permanently connected to 12V batteries as the draw is significantly less than the leackage current of the battery. This assumes the battery is > 50Ah.

Programming is via UDPI, using jtag2udpi although other prorammers can be used.

# JDY-25M

In mode 0 it operates as a transparent GATT Characteristic device with a fixed Service UUID, and characteristics. Writing to the serial porta results in devices that have connected and subsctibed to the characteristic being notified of each byte[] terminated by \r\n.

# INA219

Very simple to directly interact with over i2c. 1 config register, and 2 registers for raw voltage and raw shunt voltage. It is configured for 16V bus voltage, 12bit giving 4mv resplution, and 80mV shunt which gives  0.019mv per bit or 29mA/bit resolution. Stability appears rock solid.

# Attiny3224 sleep

The Attiny sleep is simple and allows putting the chip into deep sleep woken by a interrupt attached to the status pin of the JDY-25M. This goes high when a device connects, waking the device out of deep sleep.

In sleep the INS219 is also put to sleep, but the JDY-25 light sleeps consuming about 50uA and emtiting BLE advertisements. 

# Configuration

Configuring is done over the debug serial at 115200 baud, press h for menu. The name can be changed. 

# BLE

Service UUID is 0xFFE0, caracteristic is 0xFFE1 or 0xFFE2 supporting notify and write.

Data format uses int16 packed into a buffer 14 bytes long, big endian.

Bytes 0-1 Voltage  * 0.001 +- 32V.
Bytes 2-3 Current  * 0.01 +- 320A.
Bytes 4-5 Temperature 1 * 0.01 C +320C -273C
Bytes 6-7 Temperature 2 * 0.01 C +320C -273C
Bytes 8-9 On time in seconds
Bytes 10-11 error flag set bits indicates nature of the error.
   0x0001 == failed reading voltage.
   0x0002 == failed reading current.
   0x0004 == failed reading temp1.
   0x0008 == failed reading temp2.
Byte 12 == \r
Byte 13 == \n

# PCB

# Todo

* [x] Implement temperature sensors
* [ ] Build temperature sensors
* [ ] calibrate

## KiCad design pcb/BLEBatteryMonitor.kicad_pcb

Parts:
C101: 1uF; C_1206
C102: 10uF; C_0805
C103: 100nF; C_0805
D101: LED; LED_0805
IC101: ATTINY3224-SS; SOIC-14_3.9x8.7mm_Pitch1.27mm
K101: CONN_3; Pin_Header_Straight_1x03
P101, P105: CONN_1; M5Bolt
P102, P103: CONN_2; Pin_Header_Straight_1x02
P104: DEBUG; Pin_Header_Straight_1x05
R101: 270R; R_0805
R102, R103: 10K; R_0805
R104: 2.2K; R_0805
TH101: THERMISTOR; Resistor_Horizontal_RM7mm
U101: NCP1117ST50T3G; SOT-223-3Lead_TabPin2
U102: INA219-module; INA219Module
U103: NCP718; SOT-23-5
U104: JDY25M; JDY-25M

Connections:
3V: C102.2, C103.1, IC101.1 (VCC), P104.1, R102.1, R103.1, U101.2 (VO), U102.1 (Vcc), U103.5 (OUT), U104.1 (Vcc)
GND: C101.2, C102.1, C103.2, IC101.14 (GND), K101.3, P102.2 (PM), P103.2 (PM), P104.2, R104.1, U101.1 (GND), U102.2 (GND), U103.2 (GND), U104.24 (GND)
IN+: K101.1, P101.1, TH101.2, U102.6 (IN+)
IN-: K101.2 (PM), P105.1, U102.5 (IN-)
LED: D101.1 (A), IC101.13 ((XCK/SCK/AIN3)PA3)
unnamed: C101.1, TH101.1, U101.3 (VI), U103.1 (IN)
unnamed: D101.2 (K), R104.2
unnamed: IC101.10 ((UDPI/RESET)_PA0), R101.2
RESET: IC101.5 (PA7(AIN7/EVOUTA)), U104.23 (RST)
RS-RX: IC101.6 (PB3(RX0/TOSC1)), U104.19 (TXD)
RS-TX: IC101.7 (PB2(Tx0/TOSC2/EVOUTB)), U104.20 (RXD)
RX: IC101.12 ((RX1/MISO/AIN2)PA2), P104.3
SCL: IC101.9 ((AIN11/SCL)PB0), U102.3 (SCL)
SDA: IC101.8 ((AIN10/SDA)PB1), U102.4 (SDA)
TEMP1: IC101.2 (PA4(AIN4/XDIR/SS)), P102.1, R102.2
TEMP2: IC101.3 (PA5(AIN5/OUT)), P103.1, R103.2
TX: IC101.11 ((TX1/MOSI/AIN1)PA1), P104.4
UDPI: P104.5, R101.1
WAKEUP: IC101.4 (PA6(AIN6)), U104.6 (Stat)

Notes on the sheet:
Wakeup is on an Async interrupt pin Do not move.
https://github.com/SpenceKonde/megaTinyCore/blob/e59fc3046dd69f951497506e8f441a6818c28be5/megaavr/extras/PowerSave.md LDL117 has 250uA Iq and has input of 20V https://www.st.com/resource/en/datasheet/ldl1117.pdf

Board: 2 copper layers, 64.6 x 47.9 mm, 20 parts (0 on the bottom side), 19 nets.

## Code that names these connections

File src/main.cpp:

#include <Arduino.h>
#include <Wire.h>

#include <avr/sleep.h>
#include "commandline.h"
#include "ina219.h"
#include "ntcsensor.h"
#include "jdy25m.h"

// pins
#define WAKEUP_PIN    PIN_PA6  // hardware pin 4
#define RESET_PIN     PIN_PA7  // hardware pin 5
#define TEMP_NTC1_PIN PIN_PA4  // hardware pin 2
#define TEMP_NTC2_PIN PIN_PA5  // hardware pin 3
#define LED_PIN       PIN_PA3  // hardware pin 13

// JDY25M is on RX0/TX0 Serial
// Debug header is on Serial1

#define jdy25mUart Serial
#define debug Serial1

Ina219 ina219(&debug);
CommandLine commandLine(&debug);
NtcSensor ntcSensor(&debug);
Jdy25m jdy25m(RESET_PIN, &jdy25mUart, &debug);

unsigned long lastSend = millis();
// must be volatile so the compiler doesnt optimnise
volatile bool shouldWakeUp=false;
bool ina219Ok = true;
bool jdy25mOk = true;

#define OUTPUT_BUFFER_LEN 12
uint8_t outputBuffer[OUTPUT_BUFFER_LEN];

// see https://github.com/SpenceKonde/megaTinyCore/blob/e59fc3046dd69f951497506e8f441a6818c28be5/megaavr/extras/Ref_PinInterrupts.md
// Used to detect wake up from sleep.
ISR(PORTA_PORT_vect) {
	byte flags = VPORTA.INTFLAGS;
	// wake up pin is pin PA 6
	if (flags & (1 << 6) ) {
		shouldWakeUp=true;
		VPORTA.INTFLAGS |= (1 << 6); // clear the flag, so it doesnt fire continuously.
	}
}

// in role 0 these are hard coded into the JDY-25M device
// and cant be changed
// They appear as services and Gatt characteristics with write+notify
// but this is only for reference. the AT+MESH command decides where the 
// data is going based on the CMD.
// These are here for reference only.
#define JDY25_UUID 0xFFE0  
#define JDY25_TRANSPARENT_CHARACTERISTIC_CH0 0xFFE1
#define JDY25_TRANSPARENT_CHARACTERISTIC_CH1 0xFFE2
#define JDY25_MESH_DATA_CHARACTERISTIC 0xFFE3

void flashLed(int n) {
	for ( int i = 0; i < n; i++) {
		digitalWrite(LED_PIN, HIGH);
		delay(250);
		commandLine.checkCommand();
		digitalWrite(LED_PIN, LOW);
		delay(250);
		commandLine.checkCommand();
	}
	for ( int i = 0; i < 8; i++) {
		delay(250);
		commandLine.checkCommand();
	}

}

void dumpBuffer() {
	for (int i = 0; i < OUTPUT_BUFFER_LEN; i++) {
		if ( outputBuffer[i] < 0x10 ) {
			debug.print('0');
		}
		debug.print(outputBuffer[i],HEX);
	}
	debug.println("");
}

void setup() {

  pinMode(WAKEUP_PIN, INPUT);
  pinMode(RESET_PIN, OUTPUT);
  pinMode(LED_PIN, OUTPUT);
  // Open serial communications and wait for port to open:
  debug.begin(115200);

  // try 115200, if that fails drop back to 9600 and set.

  if ( ina219.begin() != I2C_OK) {
  	ina219Ok = false;
	  debug.print("Failed to find INA219 chip, error:");
	  debug.println(ina219.getError());
  }
  commandLine.begin();

  ntcSensor.addSensor(TEMP_NTC1_PIN, 0);
  ntcSensor.addSensor(TEMP_NTC2_PIN, 1);
  ntcSensor.begin();

  commandLine.diagnosticsEnabled =true;

  // These only work when the device is powered on or the RST 11 on device) pin is pulled low
  // reset the device.
  if ( !jdy25m.begin((const char *)&commandLine.deviceName[0]) ) {
	  debug.print("Failed to find JDY25M board");
	  jdy25mOk = false;
  }

	 if (ina219Ok && jdy25mOk ) {
	 	 flashLed(2);
	 } 
	 if (!ina219Ok) {
	 	 debug.println("INA219 not responding");
	 }
	 if (!jdy25mOk) {
	 	 debug.println("JDY25M not responding");

	 }

	 set_sleep_mode(SLEEP_MODE_PWR_DOWN);
	 sleep_enable();

}

void loop() {
	static unsigned long last = 60000;
	static int state = 0;
	unsigned long now = millis();
	if ( !(ina219Ok && jdy25mOk )) {
	 	if ( !ina219Ok ) {
	 		flashLed(3);
	 	} 
	 	if ( !jdy25mOk) {
	 		flashLed(5);
	 	}
	} else if ( (now-last) > 60000 || digitalRead(WAKEUP_PIN) == HIGH ) {
	  if ( commandLine.checkCommand() ) {
	  	last = millis();
	  }

	  jdy25m.echo();

	  unsigned long now = millis();
	  if ( (now-lastSend) > 1000 ) {
			ina219.enableLogging(commandLine.diagnosticsEnabled);
			ntcSensor.enableLogging(commandLine.diagnosticsEnabled);
			jdy25m.enableLogging(commandLine.diagnosticsEnabled);
	  	uint16_t error = 0x0000;
	  	// read the ina219 and notify BLE.
	  	lastSend = now;
	  	digitalWrite(LED_PIN, CHANGE);
	  	// 1mV per bit, +-32V max
  		int16_t voltage = (int16_t)(1000.0*ina219.getVoltage());
  		if ( ina219.getError() != I2C_OK) {
  			error |= 0x0001;
  		}
  		// 10mA per bit 320A  0.01*32000
  	  int16_t current = (int16_t)(100*ina219.getCurrent());
  		if ( ina219.getError() != I2C_OK) {
  			error |= 0x0002;
  		}
  		// temperature 0.01C per bit, 320C max
  		ntcSensor.refresh();
  		int16_t temp1 = ntcSensor.getTemperature(0);
  		int16_t temp2 = ntcSensor.getTemperature(1);
  		uint16_t tons = millis()/1000;
  		outputBuffer[0] = voltage>>8;
  		outputBuffer[1] = voltage&0xff;
  		outputBuffer[2] = current>>8;
  		outputBuffer[3] = current&0xff;
  		outputBuffer[4] = temp1>>8;
  		outputBuffer[5] = temp1&0xff;
  		outputBuffer[6] = temp2>>8;
  		outputBuffer[7] = temp2&0xff;
  		outputBuffer[8] = tons>>8;
  		outputBuffer[9] = tons&0xff;
  		outputBuffer[10] = error>>8;
  		outputBuffer[11] = error&0xff;
  		jdy25m.notify(outputBuffer,OUTPUT_BUFFER_LEN);
  		if ( commandLine.diagnosticsEnabled ) {
  			debug.print(" v=");debug.print(voltage);
  			debug.print(" c=");debug.print(current);
  			debug.print(" t1=");debug.print(temp1);
  			debug.print(" t2=");debug.print(temp2);
  			debug.print(" tons=");debug.print(tons);
  			debug.print(" error=");debug.print(error);
  			debug.print(" gatt=");
	  		dumpBuffer();
  		}
	  }

	} else {
		delay(100); // to avoid bouncing
		// clear the read buffer.
		// The JDY25 will go into sleep mode when the last connection is removed
		// It will also take the WAKE PIN to low.
		// turn off the ina219
		ina219.powerDown(true);
		jdy25m.powerDown(true);
		// turn off anything else that can be.
	  digitalWrite(LED_PIN, LOW);
		debug.print(millis());
		debug.println(F("Sleeping "));
		debug.flush();
		delay(100); // to avoid bouncing
		// sleep

		shouldWakeUp = false;
		USART0.CTRLB != 1<<4; // set the SFDEN bit, start of frame detection.
		// clear the flag on pin6
		VPORTA.INTFLAGS |= (1 << 6);
		// enable the ISR on pin6 rising, with pullup.
		// 0xx010 == rising.
		// 0x1xxx == input pullup
		PORTA.PIN6CTRL  = 0b00001010;
		do {
			sleep_cpu();
		} while (!shouldWakeUp);
		// diable the ISR
		// 0xx000 == disabled
		// 0x1xxx == input pullup
		PORTA.PIN6CTRL = 0b00001000;

		debug.print(millis());
		debug.println(F("Woke up "));
		debug.flush();
		// clear the read buffer.
		jdy25m.powerDown(false);
	  // restart ina219
		ina219.powerDown(false);
		delay(10); // to avoid bouncing

	}
}

## Commit log

2022-09-14 Made libs easier to work with
2023-09-09 Fixed 49day overflows
